# Keil uVision project CSBv5.uvprojx, settings and files
target CSB (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\User;..\..\Hardware;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32F10x_DSP_Lib\inc;..\..\Libraries\STemWin532\Config;..\..\Libraries\STemWin532\inc;..\..\Graphics
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: main.c bsp.c bsp.h stm32xxx_it.c stm32f10x_conf.h
  group Hardware
    ../../Hardware/: sys.c delay.c ad.c usart.c pwm.c tft.c key.c GearsSwitch.c ultrasonic.c rtc.c inter_flash.c save.c
  group Graphics
    ../../Graphics/: GUI_APP.C GBLOGO.c ICON.c
  group Core
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
    ../../Libraries/STM32F10x_DSP_Lib/src/: cr4_fft_1024_stm32.s
  group STemWin532
    ../../Libraries/STemWin532/OS/: GUI_X.c
    ../../Libraries/STemWin532/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../../Libraries/STemWin532/Lib/: STemWin532_CM3_Keil.lib
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group Readme
    ../../Readme/: 01_软件更新说明.txt 02_声强协议.txt note1.txt
